# Keil uVision project fap_backplane.uvprojx, settings and files
target fap_backplane (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: fap_backplane
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../../../Inc;../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../../../Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../../../Src/: main.c usb_device.c usbd_desc.c usbd_cdc_if.c usbd_conf.c stm32f0xx_it.c stm32f0xx_hal_msp.c delay_us.c hmi_lcd.c softserial.c cpu_ctrl.c helpers.c my_usb.c
    ../../../Inc/: delay_us.h hmi_lcd.h mxconstants.h softserial.h stm32f0xx_hal_conf.h stm32f0xx_it.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h cpu_ctrl.h helpers.h my_usb.h shared.h
  group Middlewares/USB_Device_Library
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c
software components: CMSIS:CORE 4.1.0
